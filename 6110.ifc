Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-24T22:57:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 24 22:57:29 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{5C5D1BAB-48A5-462F-9E53-959F287CDCA1}\ifc * Database version: 5507 * Database creation date: Fri Aug 24 22:57:28 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 24 22:57:29 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 24 22:57:29 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6110 Washbasin faucet, 230 V, 6110:6110 Washbasin faucet, 230 V:366132
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 16 mm; NominalDepth: 216 mm; NominalHeight: 175.5 mm; NominalWidth: 90 mm; Projection: 120 mm
Type - Electrical(Type) - Electrical Connection: 230 VAC; Operating Voltage: 230 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6110; ConvergoRefNr: 0087-1809-0124-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 24/08/2018
Type - Green Building Properties(Type) - EAN Number: 6414150035524; EMC Directive: 89/336/EEC; EN Standard: EN 15091; ETA-Danmark: VA 1.42/19220; LVI Number: 6116150; Noise Class: I (ISO 3822); NRF Number: 4200045; Protection Class: IP 67; RSK Number: 8553425; STF Certificate: STF VTT-RTH-00112-11; VVS Number: 704275504
Type - Identity Data(Type) - Class: Fixed connection, touchless; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 6110 Washbasin faucet, 230 V; Name_en: 6110 Washbasin faucet, 230 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6110; Product Datasheet: https://www.oras.com/datasheet/6110/en; Product Family: Oras Electra; Product URL: https://www.oras.com/en/products/oras/product/6110; Type Name: 6110 Washbasin faucet, 230 V; Usage Group: Offices, personnel sanitary facilities;Gas stations;Airports, Railway stations;Sports stadiums;Hotels, Restaurants, Café
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Vandal-proof construction; Afterflow Period: 1; Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00388461 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/110315_PDM_945859_5_(945859-02-14).pdf; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Max Flow Period: 120; Mechanical Parts: Litter filter(s); Pressure Loss With Flow 01ls: 170000 Pa; Recognition Range: 0 - 40 cm; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP6110/
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6110; Features: Fixed connection, touchless; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6110; Name: 6110 Washbasin faucet, 230 V; ReplacementCost: n/a; Shape: Sculptured; Size: 90x215x175 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6110; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6110 Washbasin faucet, 230 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0750427 m2; Volume: 0.00342312 m3
Identity Data - Mark: 25
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6110: 6110 Washbasin faucet, 230 V; Family and Type: 6110: 6110 Washbasin faucet, 230 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6110: 6110 Washbasin faucet, 230 V; Type Id: 6110: 6110 Washbasin faucet, 230 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
